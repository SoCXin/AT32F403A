# Keil uVision project MPU6050.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LED +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;..\usart;..\iic_analog;..\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c
  group ST_Lib
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_usart.c stm32f0xx_rcc.c stm32f0xx_tim.c
  group My_Lib
    ../My_Lib/LED/: led.c
    ../usart/: USART1.c
    ../iic_analog/: bsp_i2c.c
    ../MPU6050/: MPU6050.c
  group System
    ../System/startup/: startup_stm32f0xx_ld.s
    ../System/CMSIS/: core_cm0.h core_cm0plus.h stm32f0xx.h stm32f0xx_conf.h system_stm32f0xx.c system_stm32f0xx.h
